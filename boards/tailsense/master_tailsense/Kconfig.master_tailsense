## boards/tailsense/master_tailsense/board.yml
```yaml
board:
  name: master_tailsense
  vendor: tailsense
  socs:
  - name: nrf9161
    variants:
    - name: ns
```
